# Keil uVision project NOVO.uvprojx, settings and files
target Target 1 (ARM-GNU)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NOVO
  group Source Startup
    ./: startup_gcc.c hello.c
    ./lib/: libdriver.a driverlib.a
  group UART
    ./: uartstdio.c pinout.c
    ./: gpio.c cpu.c
  group context
    ./context/: contexts.c ucontext_asm.s ucontext.c
  group tcb
    ./tcb/: pingpong-tasks1.c ppos_core.c pingpong-tasks2.c pingpong-tasks3.c pingpong-dispatcher.c pingpong-dispatcher.h pingpong-scheduler.c pingpong-preempcao.c
  group queue
    ./queue/: queue.c queue.h
